# Keil uVision project project.uvprojx, settings and files
target stm32f103xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103xx +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER, USE_HAL_DRIVER, STM32F103xB
  c include: applications;..\..\src;..\..\port;..\htd_task;..\htd_task\src\common;..\htd_task\src\memheap;..\htd_task\src;..\htd_task\port;..\htd_task\external_lib;..\htd_task\external_lib\segger_rtt;.;..\libraries;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\stm32f1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: app_console_segger_rtt.c app_main.c
  group htd_console
    ../../src/: htd_console_history.c htd_console_process.c
    ../../port/: htd_console_printf_fmt.c
  group htd_task
    ../htd_task/external_lib/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../htd_task/port/: htd_task_port.c
    ../htd_task/src/common/: htd_base16.c htd_base32.c htd_base64.c htd_bitmap.c htd_fifo.c htd_log.c htd_printf_fmt.c htd_time.c
    ../htd_task/src/: htd_task.c htd_task_freertos.c htd_task_nos.c htd_task_nos_sch.c htd_task_sch.c htd_task_thread_sch.c htd_task_win32_sdl2.c
    ../htd_task/src/memheap/: htd_memheap_ff.c htd_memheap_sram_dev.c
  group stm32_libraries
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/stm32f1xx/Source/Templates/: system_stm32f1xx.c
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group stm32f103
    board/: stm32f1xx_hal_msp.c startup_stm32f103xb.s app_board.c stm32f1xx_it.c
software components: CMSIS:CORE 5.4.0
